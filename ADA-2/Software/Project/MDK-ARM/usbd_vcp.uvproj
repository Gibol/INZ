# Keil uVision project usbd_vcp.uvproj, settings and files
target STM32F4Discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ADA-2 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_USB_OTG_FS
  c misc: --c99
  c include: ..\;..\inc;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\Libraries\STM32_USB_Device_Library\Class\cdc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../src/: usb_bsp.c usbd_usr.c usbd_cdc_vcp.c stm32fxxx_it.c usbd_desc.c main.c
  group USB Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c
  group USB Device
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_req.c usbd_core.c usbd_ioreq.c
    ../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group STM32F4xx
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_tim.c misc.c
